# Keil uVision project lora_node.uvproj, settings and files
target lora_node (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lora_node +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --C99
  c include: .;..\libs\stdlib\CMSIS\CM3\CoreSupport;..\libs\stdlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\libs\stdlib\STM32F10x_StdPeriph_Driver\inc;..\app;..\nCore;..\nCore\inc;..\ncore\lora;..\ncore\lora\sx126x;..\nCore\hardware;..\nCore\hardware\sal;..\rtos\contiki\core;..\rtos\contiki\core\sys;..\rtos\contiki\cpu;..\ncore\hardware\i2c
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s
  group CMSIS
    ../libs/stdlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../libs/stdlib/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32F10x_StdPeriph_Driver
    ../libs/stdlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group App
    ../app/: main.c lora_app.c
  group ncore
    ../ncore/: stm32f10x_it.c ntimer.c fw_env.c mbus_host.c date.c
    ../ncore/hardware/: bsp_crc.c bsp_debug_usart.c bsp_internal_flash.c bsp_iwdg.c bsp_led.c bsp_modbus_timer.c bsp_modbus_uart.c bsp_rcc.c bsp_sx126x.c bsp_io_board.c bsp_rtc.c bsp_di.c bsp_ina219.c bsp_i2c.c
  group lora
    ../ncore/lora/sx126x/: sx126x.c
    ../ncore/lora/: radio.c lora_mac.c
    ../ncore/: lora_lib.c
  group contiki_core
    ../rtos/contiki/core/sys/: autostart.c etimer.c process.c timer.c
  group contiki_cpu
    ../rtos/contiki/cpu/: clock.c
